# Keil uVision project NSUC1602_FOC.uvprojx, settings and files
target NSUC1602 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NSUC1602 Generic
  pack: Novosns.NSUC1602.1.0.0
  cpu: IRAM(0x20000000,0x01000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NSUC1602_Eval +hex
  AfterMake: KeilOoutput.bat !L $L@L
  AfterMake: python.exe "$P\" "../User/Include/global.h" #L "Objects"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM3
  c misc: --diag_suppress=1
  c include: .\source;..\system;..\driver\inc;..\system\CMSIS;..\..\common\System\CMSIS;..\..\common\Driver\inc;..\..\common\System;..\User\NovosnsFoc\inc;..\User;..\User\NovosnsMotorMath\inc;..\User\DebugTools\inc;..\User\LIN;..\User\FaultDiagnosis\inc;..\User\NovosnsMtrAdvance\inc;..\..\common\Driver\inc;..\User\Include;..\User\FOCLIB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry=Reset_Handler
  group Startup
    ../../common/System/: startup_NSUC1602.s
  group Main
    ../user/: main.c
    ../User/: lin_appl.c pwm_appl.c NTCdrive.c
    ../User/Source/: motor_state_ctrl.c derating_control.c testFun.c sleep_control.c
  group System
    ../../common/System/: handler.c Retarget.c sysport.c system.c
  group Driver
    ../../common/Driver/src/: SysTick.c uart.c SysTick_isr.c
  group NovosnsMotorLib
    ../User/NovosnsMotorMath/src/: NSUC1602_Motor_Math.lib
  group NovosnsMotorAdv
    ../User/NovosnsMtrAdvance/src/: mtr_adv_init.c
  group FocApp
    ../User/NovosnsFoc/src/: foc_init.c foc_paras.c nvsns_foc.c state_machine.c
  group DebugTools
    ../User/DebugTools/src/: freemaster_appcmd.c freemaster_bdm.c freemaster_can.c freemaster_Kxx.c freemaster_lin.c freemaster_pipes.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c
  group LIN
    ../User/LIN/: lin_api_appl.c lin_config.c lin_identification_and_configuration.c lin_nvr.c lin_api.lib lin_init.c
  group FaultDiagnosis
    ../User/FaultDiagnosis/src/: fault_diagnose.c fault_handler.c fault_init.c
  group FOCLIB
    ../User/FOCLIB/src/: foclib_init.c FOCLIB_VOLV_251209.lib
